# Keil uVision project SL8631E.uvproj, settings and files
target SL8631E (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: sl8631_EV41BL5372-2016-3-4 +hex
  c flags: wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\CMSIS;..\FWlib\inc;..\USER\inc;..\APP;..\BSP;..\uCOS-II\Ports;..\uCOS-II\Source;..\USER\inc\object;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../USER/src/: main.c stm32f10x_it.c SystemInit.c CanQuery.c CanSet.c CanTask.c CreateTask.c Display.c DogTask.c OpenClose.c EnergyCollection.c Execute.c Flash.c List.c Timer.c Wireless.c StorageManager.c SensorCollection.c Object.c lux.c InductionCollection.c
  group FWlib
    ../FWlib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group BSP
    ../BSP/: BL5372.c BSP.c delay.c JF24D.c STM32_Init.c STM32_USART.c DS18B20.c tm1637.c sd2068.c RTCcalibration.c
  group APP
    ../APP/: os_cfg.h os_cfg_r.h os_cfg_V2.86.h os_cpu.h app_cfg.h
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Readme
    ../: readme.txt
